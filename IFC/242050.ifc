Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2x3 Coordination View
File name: D:\Jonas\Documents\Cadfocus\Ostnor\2012\CAD-objekt_2012-09-28\CADFOCUS\242050\AutoCAD Architecture\242050.ifc
Time: 2012-10-17T11:31:27
Author: - -
Organization: Mora Armatur, Ostnor AB
Written by: Eurostep IFC Toolbox - 1.0
Made in: AutoCAD Architecture 2009 Build 5.7.68.0

# IfcProject, 242050
LongName: 242050
PSET_ACA_DISPLAY_SET - ACA_DISPLAY_CONFIG_ON_EXPORT: 02 - Normal detaljering; ACA_DISPLAY_SET_ON_EXPORT: 3D Normal

# IfcBuilding, 242050
ElevationOfRefHeight: 0 mm; ElevationOfTerrain: 0 mm

# IfcBuildingElementProxy: 242050, BUILDINGELEMENTPROXY(1)
In: 242050
Description: Mora Cera K7 Kitchen Mixer chrome
